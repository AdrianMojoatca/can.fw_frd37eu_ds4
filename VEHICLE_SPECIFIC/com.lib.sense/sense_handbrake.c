/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: sense_handbrake.c 4280 2012-11-16 10:43:59Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/
#include "sense_private.h"
/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/

/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/
Boolean hb_on_3B3;

UInt8 hb_debounce = 0;

/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

//--------------------------------------------------------------------------//

void sense_handbrake_3BC( Can_Msg *can_msg ) 
{    
    if ( (DATA[6]&0x0F) == 0x0F ) 
		sense_rs_handbrake_can(TRUE);
	else 
		sense_rs_handbrake_can(FALSE);
}


// vers. 1_11 - 10_07_2019
void sense_handbrake_213( Can_Msg *can_msg ) 
{    
	
	if (hb_on_3B3 == TRUE ) return;  // vers. 1_17 - fiesta
	
	if (!get_ign_status() ) 
	{
		sense_rs_handbrake_can(TRUE);
		return;
	}

	if ( (DATA[3]&0xF0) != 0x00 ) 
	{
		hb_debounce = 0;
		sense_rs_handbrake_can(TRUE);
	}
	else 
	{
		hb_debounce++;
		if ( hb_debounce == 1 )
		{
			hb_debounce = 0;
			sense_rs_handbrake_can(FALSE);
		}			
		
		
	}
}
	
//--------------------------------------------------------------------------//

// vers. 1_11 - 10_07_2019
void sense_handbrake_3B3( Can_Msg *can_msg ) 
{    
    if (!get_ign_status() && (hb_on_3B3 == TRUE) ) 
	{
		sense_rs_handbrake_can(TRUE);
		return;
	}
	if ( ((DATA[6]&0x80) == 0x80) )
	{ 
		sense_rs_handbrake_can(TRUE);
		hb_on_3B3 = TRUE;
	}
	else if ( hb_on_3B3 == TRUE )
	{
		sense_rs_handbrake_can(FALSE);
	}
}