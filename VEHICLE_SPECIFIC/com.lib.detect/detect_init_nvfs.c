/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: detect_init_nvfs.c 4241 2012-10-25 18:16:25Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/
#include "detect_private.h"

#include "nvfs_usr.h"
/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/

/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/
/*extern*/ const NVFS_Entry_Name nvfs_gearbox_feat   ; // gearbox type; 0x00 unknown , 0x01 manual, 0x02 automatic
/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

//--------------------------------------------------------------------------//

Boolean detect_init_nvfs( void )
{
    if( (nvfs_rd( nvfs_fw_data , &car) == NVFS_OK) && DETECT_CAR_FOUND()) 
    {
        TRACE("\n\r[DETECT_CAR_FOUND]\n\r");

        led_detect_done();
                
        return TRUE ; 
    }
                    
    TRACE("\n\r[DETECT_CAR_NOT_FOUND]\n\r");

    if( nvfs_wr_create( nvfs_fw_data , &car , sizeof( car )) == NVFS_OK  )
    {                        
        if( nvfs_wr( nvfs_fw_data , &car ) == NVFS_OK )
        {                        
            nvram_usr_commit() ;             
        }        
    }
    
    return FALSE ;
}

//--------------------------------------------------------------------------//

void detect_reset_init( void )
{
    reset_register( (Reset_Func)detect_nvfs_reset );     
}

//--------------------------------------------------------------------------//

void detect_nvfs_reset( void )
{
    nvfs_delete( nvfs_fw_data ) ; 

	nvfs_delete( nvfs_gearbox_feat );

    nvram_usr_commit() ; 
}

//--------------------------------------------------------------------------//
