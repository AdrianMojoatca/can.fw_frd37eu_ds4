/*<#======================================================================#>*/
/*                          FILE HEADER GOES HERE                           */
/*<#======================================================================#>*/

/*==========================================================================*/
// $Id: func_arm.c 2977 2011-07-18 16:29:02Z florin.olariu $
/*==========================================================================*/

/*==========================================================================*/
/*                             I N C L U D E S                              */
/*==========================================================================*/
#include "func_private.h"
/*==========================================================================*/
/*      D E F I N E S  -  E N U M E R A T I O N S  -  T Y P E D E F S       */
/*==========================================================================*/

/*==========================================================================*/
/*                  F U N C T I O N   P R O T O T Y P E S                   */
/*==========================================================================*/

/*==========================================================================*/
/*                            V A R I A B L E S                             */
/*==========================================================================*/
static Boolean func_do_lock   = FALSE;
static Boolean func_do_unlock = FALSE; 
/*==========================================================================*/
/*                 F U N C T I O N   D E F I N I T I O N S                  */
/*==========================================================================*/

/*--------------------------------------------------------------------------*/

void func_oem_lock_start( void  )
{
     return;	// ADI - 13.01.2017

	 if( get_rs_gwr() )
     {
         func_do_lock = TRUE;
         
         func_lock_start();
     }
}

/*--------------------------------------------------------------------------*/

Boolean func_oem_lock_exec( void )
{
    return func_do_lock ? func_lock_exec():FALSE ; 
}

/*--------------------------------------------------------------------------*/

void func_oem_lock_stop( void )
{
    if( func_do_lock )
    {
        func_lock_stop();
        
        func_do_lock = FALSE;
    }
}

/*--------------------------------------------------------------------------*/
/*--------------------------------------------------------------------------*/
/*--------------------------------------------------------------------------*/

void func_oem_unlock_start( void  )
{
    return;	// ADI - 13.01.2017

	if( get_rs_gwr() )
    {
        func_do_unlock = TRUE;
         
        func_unlock_all_start();
    }
}

/*--------------------------------------------------------------------------*/

Boolean func_oem_unlock_exec( void )
{
    return func_do_unlock ? func_unlock_all_exec():FALSE ; 
}

/*--------------------------------------------------------------------------*/

void func_oem_unlock_stop( void )
{
    if( func_do_unlock )
    {
        func_unlock_all_stop();
        
        func_do_unlock = FALSE;
    }
}

/*--------------------------------------------------------------------------*/
/*--------------------------------------------------------------------------*/

void func_oem_trunk_start( void  )
{
    return;	// ADI - 13.01.2017

	if( get_rs_gwr() )
    {
        func_do_unlock = TRUE;
         
        func_unlock_all_start();
    }
}

/*--------------------------------------------------------------------------*/

Boolean func_oem_trunk_exec( void )
{
    return func_do_unlock ? func_unlock_all_exec():FALSE ; 
}

/*--------------------------------------------------------------------------*/

void func_oem_trunk_stop( void )
{
    if( func_do_unlock )
    {
        func_unlock_all_stop();
        
        func_do_unlock = FALSE;
    }
}

/*--------------------------------------------------------------------------*/


